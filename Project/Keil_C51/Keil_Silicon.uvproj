# Keil uVision project Keil_Silicon.uvproj, settings and files
target Debug (MCS-51)
  device: EFM8UB20F64G-QFP32 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: Keil_Silicon +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\SrcCode\Bsp\Inc;..\..\SrcCode\Logic\Inc;..\..\SrcCode\Middle\Gui\Inc;..\..\SrcCode\Middle\Input\Inc;..\..\SdkTool\Si8051Base;..\..\SdkTool\EFM8UB2\Inc;..\..\SdkTool\EFM8UB2\Perip\Inc;..\..\SdkTool\EFM8UB2\Xpress\Inc
  group SrcCode\Bsp\Inc
    ../../SrcCode/Bsp/Inc/: InitDevice.h ReMap.h TypeDef.h
  group SrcCode\Bsp\Core
    ../../SrcCode/Bsp/Core/: InitDevice.c A_StartUp.a A_AppInit.a
  group SrcCode\Logic\Inc
    ../../SrcCode/Logic/Inc/: AppDef.h Global.h Stablizer.h Esc.h Battery.h Sterring.h
  group SrcCode\Logic\Core
    ../../SrcCode/Logic/Core/: Main.c Global.c Esc.c Stablizer.c LipoCells.c Sterring.c
  group SrcCode\Middle\Gui\Inc
    ../../SrcCode/Middle/Gui/Inc/: LcdBase.h LcdDraw.h Page.h PageRes.h
  group SrcCode\Middle\Gui\Core
    ../../SrcCode/Middle/Gui/Core/: PageRes.c LcdBsae.c LcdDraw.c Page.c
  group SrcCode\Middle\Gui\Page
    ../../SrcCode/Middle/Gui/Page/: PageEsc.c PageEsc1th.c PageEsc2th.c PageEsc3th.c PageLipoCells.c PageStabilizer.c PageStabilizerBuild.c PageStabilizerMode.c PageStabilizerPitchGain.c PageStabilizerRollGain.c PageStabilizerYawGain.c PageSteering.c
  group SrcCode\Middle\Input\Inc
    ../../SrcCode/Middle/Input/Inc/: InputBtnBsp.h InputBtn.h
  group SrcCode\Middle\Input\Core
    ../../SrcCode/Middle/Input/Core/: InputBtn.c InputBtnBsp.c
  group SdkTool\Si8051Base
    ../../SdkTool/Si8051Base/: compiler_defs.h endian.h si_toolchain.h stdint.h
  group SdkTool\EFM8UB2\Inc
    ../../SdkTool/EFM8UB2/Inc/: SI_EFM8UB2_Defs.h SI_EFM8UB2_Defs.inc SI_EFM8UB2_Devices.h SI_EFM8UB2_Register_Enums.h SI_EFM8UB2_Register_Enums.inc
  group Readme
    ../../Readme/: Readme.txt
target Release (MCS-51)
  device: EFM8UB20F64G-QFP32 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: Keil_Silicon +hex
  c flags: SizeSpeed=1
  c include: as above
